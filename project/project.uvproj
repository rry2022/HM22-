# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: SN8F5762 SONiX
  cpu: IRAM(0-0xFF) XRAM(0-0x02FF) IROM(0-0x47F5) CLOCK(32000000) DPC
  output: test +hex
  AfterMake: HexConvert.exe $D "#H"
  c flags: Optimize=8 SizeSpeed=1
  c include: .\C;.\H
  group Source Group 1
    ./: STARTUP.A51 OPTIONS_SN8F5762.A51
  group C
    ./C/: AD.c ctr.c init.c main.c test.c time.c key.c uart.c
  group H
    $TC_ROOT$/../../公司项目/陈梓铭-HM22/HM22/project/H/: AD.h ctr.h global.h init.h test.h time.h
    ./H/: key.h uart.h
